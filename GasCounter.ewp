# IAR project GasCounter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152x6 ST STM32L152x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.PreInclude: ext_src\inc\stm32l1xx_conf.h
  ICCARM.CCIncludePath2: inc; ext_src\inc; ext_src\STM32L1xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GasCounter.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ext_src\stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Src
    src/: Counter_GPIO_utils.c Counter_GSM.c Counter_Init.c Counter_Measurement.c Counter_Memory.c Counter_Misc.c Counter_PwrMgmt.c Counter_TimeMgmt.c Counter_UART.c main.c
  group Src/external
    ext_src/: startup_stm32l1xx_md.s
    ext_src/src/: system_stm32l1xx.c
  group STM32L1xx_StdPeriph_Driver
    ext_src/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
